# Repository YazawaKenichi/University

File README.md:

# University

大学の課題の内容そのままアップロードしてるのまぁまぁヤバい気はしてる。

## KiCad design minakatalab/potentiometermodule/potentiometermodule.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
H5: MountingHole; MountingHole_4mm
J1: Conn_01x03; PinSocket_1x03_P2.54mm_Vertical
RV1: R_POT; SV01A103AEA01R00

Connections:
+5V: J1.1, RV1.1
GND: J1.3, RV1.3
unnamed: J1.2, RV1.2

Board: 2 copper layers, 30.0 x 30.0 mm, 7 parts (0 on the bottom side), 3 nets.

## KiCad design hayashibalab/adrobo/PCB/adrobo.kicad_pcb

Parts:
C1, C3, C4, C5, C6, C7, C8, C11, C12, C13, C14: 0.1u; C_0603_1608Metric
C2: 100u; CP_Elec_6.3x5.9
C15: 4.7u; C_0603_1608Metric
D1, D2, D3, D4, D5, D11, D12, D14, D15, D16, D17, D18, D19: 1N4148W; D_SOD-123
D6, D7, D9, D10, D13, D20: LED; LED_0603_1608Metric
D8: 3.3V; SOD323F
FB1: Filter; L_0603_1608Metric
J1: Batt; PinHeader_1x02_P2.54mm_Vertical
J2: ADC; PinHeader_3x05_P2.54mm_Vertical
J3: GPIO; PinHeader_3x05_P2.54mm_Vertical
J11: CN2; PinHeader_1x02_P2.54mm_Vertical
J12: CN1; PinHeader_1x02_P2.54mm_Vertical
J13: UART2; PinHeader_1x05_P2.54mm_Vertical
J14: SWD; PinHeader_1x05_P2.54mm_Vertical
R1, R2, R3, R4, R5, R7: 1k; R_0603_1608Metric
R6, R8, R9, R10, R11, R16: RLED; R_0603_1608Metric
R12, R13: 10k; R_0603_1608Metric
R14, R15: 100k; R_0603_1608Metric
SW1, SW2, SW3: Switch
U1: NJM7805SDL1; Regulator
U2: SN74HC04PWR; TSSOP_P0.65mm
U3: L293E; Socket_DIP_14pin; mouser part number 511-L293E; digikey description IC MOTOR DRIVER PAR 20-PWRDIP
U4: STM32F303K8Tx; LQFP-32_7x7mm_P0.8mm
U5: NJU7223DL1; Regulator
U6: SERVO; PinHeader_3x04_P2.54mm_Vertical

Connections:
+5V: C3.1, C5.1, C7.1, J2.6, J2.7, J2.8, J2.9, J2.10, J3.6, J3.7, J3.8, J3.9, J3.10, R6.2, R8.2, R9.2, R10.2, R11.2, R16.1, U1.3 (OUT), U2.14 (VCC), U5.1 (IN), U6.5, U6.6, U6.7, U6.8
+9V: C1.1, C2.1, C4.1, D11.1 (K), D12.1 (K), D16.1 (K), D17.1 (K), J1.2, R7.1, U1.1 (IN), U3.10 (VS), U3.20 (VSS)
/MOTOROUT1: D12.2 (A), D15.1 (K), J11.1, U3.3 (OUTPUT_1)
/MOTOROUT2: D11.2 (A), D14.1 (K), J11.2, U3.8 (OUTPUT_2)
/MOTOROUT3: D17.2 (A), D19.1 (K), J12.1, U3.13 (OUTPUT_3)
/MOTOROUT4: D16.2 (A), D18.1 (K), J12.2, U3.18 (OUTPUT_4)
/OUT1: D6.1 (K), U2.2 (OUT1)
/OUT2: D7.1 (K), U2.4 (OUT2)
/OUT3: D9.1 (K), U2.6 (OUT3)
/OUT4: D10.1 (K), U2.8 (OUT4)
/OUT5: D13.1 (K), U2.10 (OUT5)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C11.2, C12.2, C13.2, C14.2, C15.2, D8.2 (A), D14.2 (A), D15.2 (A), D18.2 (A), D19.2 (A), J1.1, J2.11, J2.12, J2.13, J2.14, J2.15, J3.11, J3.12, J3.13, J3.14, J3.15, J13.5, J14.3, R13.2, SW1.2, SW2.2, SW3.2, U1.2 (GND), U2.7 (GND), U3.4 (SENSE_1), U3.5 (GND), U3.6 (GND), U3.7 (SENSE_2), U3.14 (SENSE_3), U3.15 (GND), U3.16 (GND), U3.17 (SENSE_4), U4.16 (VSS), U4.32 (VSS), U5.2 (GND), U6.9, U6.10, U6.11, U6.12
unnamed: D6.2 (A), R6.1
unnamed: D7.2 (A), R8.1
unnamed: D8.1 (K), R7.2, U3.1 (CHIP_ENABLE_1), U3.11 (CHIP_ENABLE_2)
unnamed: D9.2 (A), R9.1
unnamed: D10.2 (A), R10.1
unnamed: D13.2 (A), R11.1
unnamed: D20.1 (K), U2.12 (OUT6)
unnamed: D20.2 (A), R16.2
unnamed: FB1.2, U4.5 (VDDA)
unnamed: J2.1, R1.1
unnamed: J2.2, R2.1
unnamed: J2.3, R3.1
unnamed: J2.4, R4.1
unnamed: J2.5, R5.1
unnamed: J13.2, J14.2, R14.2, U4.24 (PA14)
unnamed: J14.4, R15.2, U4.23 (PA13)
unnamed: R13.1, U4.31 (BOOT0)
PA0: D1.2 (A), R1.2, U4.6 (PA0)
PA1: U3.12 (INPUT_3), U4.7 (PA1)
PA3: U3.19 (INPUT_4), U4.9 (PA3)
PA4: D2.2 (A), R2.2, U4.10 (PA4)
PA5: D3.2 (A), R3.2, U4.11 (PA5)
PA6: D4.2 (A), R4.2, U4.12 (PA6)
PA7: D5.2 (A), R5.2, U4.13 (PA7)
PA8: U4.18 (PA8), U6.1
PA9: U4.19 (PA9), U6.2
PA10: U4.20 (PA10), U6.3
PA11: U4.21 (PA11), U6.4
PA12: J3.1, U2.1 (IN1), U4.22 (PA12)
PB0: SW1.1, U4.14 (PB0)
PB1: SW2.1, U4.15 (PB1)
PB4: U3.2 (INPUT_1), U4.27 (PB4)
PB5: U3.9 (INPUT_2), U4.28 (PB5)
PB6: J3.3, U2.5 (IN3), U4.29 (PB6)
PB7: J3.2, U2.3 (IN2), U4.30 (PB7)
PF0: J3.4, U2.9 (IN4), U4.2 (PF0)
PF1: J3.5, U2.11 (IN5), U4.3 (PF1)
PWM: U2.13 (IN6), U4.26 (PB3)
RX: J13.3, U4.25 (PA15)
TX: J13.4, U4.8 (PA2)
nRST: C6.1, J14.5, R12.2, SW3.1, U4.4 (NRST)

Notes on the sheet:
ADC
GPIO
SERVO
1N4148W:順方向電圧降下が 0.715 V になるには 1.0mA 以下の電流が流れると良い。 そこから制限抵抗を計算すればよい。

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
Board: 2 copper layers, 72.0 x 56.5 mm, 66 parts (18 on the bottom side), 54 nets.

## Commit log

2021-10-13 電卓プログラムのベースとなる部分が完成した。
2021-10-13 Special Thanks と Reference を追記
2021-10-13 マージした
2021-10-17 FILE structure の学習ファイルを作成
2021-10-20 改良に改良を重ねてる
2021-10-20 しこーさくご
2021-10-21 Ubuntu ni
2021-10-21 返り値を列挙型にするの良いんじゃね！？
2021-10-22 マルチモード電卓を妥協状態で完成させた。
2021-10-27 hogehoge
2021-10-27 soiya
2021-10-30 mkdir hayashibalab
2021-11-02 何をコミットしたのかよくわからん
2021-11-14 sample1.c 追記
2021-11-14 OpenGL 自習用のフォルダを追加
2021-11-18 PACMAN が完成した
2021-11-18 何変更した？
2021-12-02 円と四角形を行ったり来たりできるようにした。
2021-12-02 一旦保存
2021-12-08 fall.c のコンパイルがなんか反映されないぞ？？？
2021-12-08 fall.cpp 作成中
2021-12-15 とりあえずPush”
2021-12-15 とりあえずコミット
2021-12-18 SD に移動
2021-12-18 generateVeloPath.c
2021-12-18 generateVeloPath.c にメモを追加
2021-12-19 Data.csv の追加
2021-12-19 Data.csv
2021-12-19 generateVeloPath
2021-12-21 レポート完成
2021-12-21 fall.cpp の完成
2021-12-21 two.cpp の追加
2021-12-21 pdf ディレクトリの追加
2021-12-23 nagaki
2021-12-23 swap file まで push してしまった...
2021-12-24 naga.c
2021-12-25 床作った！
2021-12-26 壁の作成
2021-12-26 naga.c の編集
2021-12-26 two.cpp が完成
2021-12-26 なぜかボール間の衝突処理がうまく行かない
2021-12-26 提出した！
2021-12-27 hoge
2022-01-31 drawlib.tgz を追加
2022-01-31 tar drawlib.tgz
2022-04-21 台車データの追加
